# IAR project foc_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PAC52XX ActiveSemi PAC52XX
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: IAR
  ICCARM.CCDiagSuppress: Ta022, Ta023
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\..; ..\board; ..\device; ..\pac5xxx_sdk; ..\pac5xxx_sdk\pac5xxx_boot_IAR; ..\pac5xxx_sdk\pac5xxx_drivers; ..\pac5xxx_sdk\pac5xxx_peripheral; ..\pac5xxx_sdk\pac5xxx_device; ..\..\src; ..\..\src\app; ..\..\src\comm; ..\..\src\comm\ppm; ..\..\src\comm\uart_gui; ..\..\src\control; ..\..\src\debug; ..\..\src\features; ..\..\src\features\autotune; ..\..\src\features\flash_crc_test; ..\..\src\features\ipd; ..\..\src\features\opd; ..\..\src\features\power; ..\..\src\features\sim; ..\..\src\features\stalldet; ..\..\src\isr; ..\..\src\math; ..\..\src\mpos; ..\..\src\mpos\estimator; ..\..\src\param; ..\..\src\mpos\aligngo; ..\..\src\mpos\hall; ..\..\src\startup; ..\..\src\comm\push_button; ..\..\src\features\halltune; ..\..\src\comm\lin_gui; ..\..\src\features\forceang; ..\..\src\features\buzz; ..\..\src\features\flashrw; ..\..\src\features\flashdemo; ..\..\src\debug\RTT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..; ..\..; ..\board; ..\device; ..\pac5xxx_sdk; ..\pac5xxx_sdk\pac5xxx_boot_IAR; ..\pac5xxx_sdk\pac5xxx_drivers; ..\pac5xxx_sdk\pac5xxx_peripheral; ..\..\src; ..\..\src\app; ..\..\src\comm; ..\..\src\comm\ppm; ..\..\src\comm\uart_gui; ..\..\src\control; ..\..\src\debug; ..\..\src\features; ..\..\src\features\autotune; ..\..\src\features\flash_crc_test; ..\..\src\features\ipd; ..\..\src\features\opd; ..\..\src\features\overmod; ..\..\src\features\power; ..\..\src\features\sim; ..\..\src\features\stalldet; ..\..\src\isr; ..\..\src\math; ..\..\src\mpos; ..\..\src\mpos\estimator; ..\..\src\param
  OBJCOPY.OOCOutputFile: foc_iar.srec
  prebuild: "..\..\pre_build.bat"  "$PROJ_DIR$"  iar
  postbuild: "post_build.bat" "$TARGET_PATH$" "$TARGET_BPATH$"
  ILINK.IlinkOutputFile: foc_iar.out
  ILINK.IlinkIcfFile: foc_iar.icf
  ILINK.IlinkExtraOptions: --place_holder __crc16_checksum,2,.crc_flash,4; --keep=__crc16_checksum
  ILINK.IlinkAdditionalLibs: ..\..\src\mpos\estimator\libestimator_iar.a; ..\..\src\control\libcontrol_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group pac5xxx_sdk/boot_IAR
    ../pac5xxx_sdk/pac5xxx_boot_IAR/: startup_pac5xxx_iar.s system_pac5xxx.c system_pac5xxx.h
  group pac5xxx_sdk/device
    ../pac5xxx_sdk/pac5xxx_device/: pac5210.h pac5220.h pac5222.h pac5223.h pac5232.h pac5250.h pac5253.h pac5256.h pac5285.h
  group pac5xxx_sdk/driver
    ../pac5xxx_sdk/pac5xxx_drivers/: pac5xxx_driver_adc.h pac5xxx_driver_adc_config.c pac5xxx_driver_adc_emux.c pac5xxx_driver_adc_seq.c pac5xxx_driver_arm.h pac5xxx_driver_arm_sleep.c pac5xxx_driver_config.h pac5xxx_driver_gpio.h pac5xxx_driver_gpio_interrupt.c pac5xxx_driver_gpio_io_enable.c pac5xxx_driver_i2c.h pac5xxx_driver_i2c_config.c pac5xxx_driver_i2c_int.c pac5xxx_driver_i2c_read.c pac5xxx_driver_i2c_write.c pac5xxx_driver_memctl_config.c pac5xxx_driver_memory.h pac5xxx_driver_rtc.h pac5xxx_driver_rtc_clear_if.c pac5xxx_driver_rtc_config.c pac5xxx_driver_rtc_reset.c pac5xxx_driver_socbridge.h pac5xxx_driver_socbridge_config.c pac5xxx_driver_socbridge_config_io.c pac5xxx_driver_socbridge_data.c pac5xxx_driver_spi.h pac5xxx_driver_spi_config_int.c pac5xxx_driver_spi_config_io.c pac5xxx_driver_spi_config_master.c pac5xxx_driver_spi_config_slave.c pac5xxx_driver_system.h pac5xxx_driver_system_ccs_config.c pac5xxx_driver_system_pll_config.c pac5xxx_driver_system_pll_config_mhz.c pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_tile_socbridge_burst.c pac5xxx_driver_tile_socbridge_config.c pac5xxx_driver_tile_socbridge_validate.c pac5xxx_driver_timer.h pac5xxx_driver_timer_base_config.c pac5xxx_driver_timer_base_int.c pac5xxx_driver_timer_base_int_clear.c pac5xxx_driver_timer_base_int_enable.c pac5xxx_driver_timer_capture_latch_config.c pac5xxx_driver_timer_cctrl_capture_config.c pac5xxx_driver_timer_cctrl_config.c pac5xxx_driver_timer_cctrl_int.c pac5xxx_driver_timer_clear.c pac5xxx_driver_timer_clock_config.c pac5xxx_driver_timer_dtg_config.c pac5xxx_driver_timer_set_period.c pac5xxx_driver_uart.h pac5xxx_driver_uart_config.c pac5xxx_driver_watchdog.h pac5xxx_driver_watchdog_clear_if.c pac5xxx_driver_watchdog_config.c pac5xxx_driver_watchdog_config_clock.c pac5xxx_driver_watchdog_reset.c
  group pac5xxx_sdk/peripheral
    ../pac5xxx_sdk/pac5xxx_peripheral/: pac52XX.h pac5xxx.h pac5xxx_ADC.h pac5xxx_GPIO.h pac5xxx_I2C.h pac5xxx_Memory.h pac5xxx_RTC.h pac5xxx_SocBridge.h pac5xxx_SPI.h pac5xxx_SYS.h pac5xxx_tile_DriverManager.h pac5xxx_tile_PowerManager.h pac5xxx_tile_SignalManager.h pac5xxx_tile_SystemManager.h pac5xxx_Timers.h pac5xxx_UART.h pac5xxx_WDT.h
  group src
    ../../src/: config_app.h config_debug.h config_features.h config_options.h main.c
    ../board/: config_board.h
    ../../: project_version.h
  group src/app
    ../../src/app/: adc_sample.h adccal.h app_control_sm.h app_funcs.c app_funcs.h app_main_sm.c app_mainsub_sm.c app_struct.h driver_funcs.c driver_funcs.h fault.c fault.h fault_struct.h motor_struct.h pac_init.c pac_init.h state_struct.h status_struct.h vbus_funcs.c vbus_funcs.h
  group src/board
    ../board/: board.h board_custom_1.c board_custom_1.h board_ep5222lvm1_1_1shunt.c board_ep5222lvm1_1_1shunt.h board_ep5223lvm1_1.c board_ep5223lvm1_1.h board_ep5223lvm1_1_1shunt.c board_ep5223lvm1_1_1shunt.h board_ep5223lvm1_1_1shunt_pwr2.c board_ep5223lvm1_1_1shunt_pwr2.h board_ep5250hphvm1_2.c board_ep5250hphvm1_2.h board_ep5250hphvm1_2_1shunt.c board_ep5250hphvm1_2_1shunt.h board_ep5285lvm1_1.c board_ep5285lvm1_1.h board_options.h board_pac5222evk1.c board_pac5222evk1.h board_pac5232evk1.c board_pac5232evk1.h board_pac5232evk1_1shunt.c board_pac5232evk1_1shunt.h board_pac52400evk1.c board_pac52400evk1.h board_pac5256evk1.c board_pac5256evk1.h board_pac5256evk1_1shunt.c board_pac5256evk1_1shunt.h board_pac52710evk1.c board_pac52710evk1.h board_pac52711evk1.c board_pac52711evk1.h
  group src/comm
    ../../src/comm/: comm.h comm_funcs.c comm_funcs.h comm_struct.h
  group src/comm/lin_gui
    ../../src/comm/lin_gui/: lin_gui.c lin_gui.h
  group src/comm/ppm
    ../../src/comm/ppm/: ppm.c ppm.h ppm_struct.h
  group src/comm/push_button
    ../../src/comm/push_button/: push_button.c push_button.h
  group src/comm/uart_gui
    ../../src/comm/uart_gui/: uart_gui.c uart_gui.h
  group src/control
    ../../src/control/: control_1shunt_funcs.h control_1shunt_funcs_asym.h control_1shunt_funcs_extn.h control_1shunt_struct.h control_3shunt_funcs.h control_3shunt_struct.h control_funcs.c control_funcs.h control_loop.c control_loop.h control_power1.h control_power1_funcs.h control_power1_struct.h control_power2_funcs.c control_power2_funcs.h control_power2_struct.h control_power_funcs.h control_sm.h control_struct.h foc.h foc_config.c foc_config.h foc_funcs.c foc_funcs.h foc_math.h foc_struct.h harmonic_inj_funcs.h harmonic_inj_libfuncs.h harmonic_inj_struct.h libcontrol_iar.a mod.h mod_gen.h mod_gen_funcs.h mod_ovm.h mod_ovm_funcs.c mod_ovm_funcs.h mod_ovm_struct.h mod_svm.h mtpa.h mtpa_funcs.c mtpa_funcs.h mtpa_struct.h
  group src/debug
    ../../src/debug/: control_check.h debug.c debug.h debug_capture.c debug_capture.h debug_dac.c debug_dac.h debug_das.c debug_das.h debug_display.c debug_display.h debug_export.c debug_export.h debug_paramwrite.h stack_check.c stack_check.h tm.h tm_auto_speed.c tm_paramcheck.c
    ../device/: debug_io.h
  group src/debug/RTT
    ../../src/debug/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c USER_RTT.h
  group src/device
    ../device/: device_5210.c device_5220.c device_5220.h device_5222.c device_5222.h device_5223.c device_5223.h device_5232.c device_5232.h device_52400.c device_52400.h device_5250.c device_5250.h device_5253.c device_5253.h device_5256.c device_5256.h device_52710.c device_52710.h device_52711.c device_52711.h device_5285.c device_5285.h device_options.h family_52xx.c family_52xx.h
  group src/features
    ../../src/features/: dcbus_check.c dcbus_check.h fw_funcs.c fw_funcs.h fw_struct.h satmon.c satmon.h speed_check.c speed_check.h watchdog.c watchdog.h
  group src/features/autotune
    ../../src/features/autotune/: atangdiff_libfuncs.h atune_funcs.c atune_funcs.h atune_libfuncs.h atune_struct.h libautotune_iar.a mid1_funcs.c mid1_funcs.h mid2_funcs.c mid2_funcs.h
  group src/features/buzz
    ../../src/features/buzz/: buzz_funcs.c buzz_funcs.h buzz_melodies.c buzz_struct.h
  group src/features/flash_crc_test
    ../../src/features/flash_crc_test/: checksum.c checksum.h flash_crc_checksum.c flash_crc_reset_handler.c flash_crc_test_version.h pac5xxx_flash_test.c pac5xxx_flash_test.h
  group src/features/flashdemo
    ../../src/features/flashdemo/: flashdemo.c flashdemo.h
  group src/features/flashrw
    ../../src/features/flashrw/: flash_dyadr_ctr.c flash_dyadr_ctr.h flashrw_crc8.c flashrw_crc8.h flashrw_defs.h flashrw_funcs.c flashrw_funcs.h flashrw_fxadr_ctr.c flashrw_fxadr_ctr.h flashrw_struct.h
  group src/features/forceang
    ../../src/features/forceang/: forceang_funcs.c forceang_funcs.h forceang_struct.h
  group src/features/halltune
    ../../src/features/halltune/: halltune_funcs.c halltune_funcs.h halltune_struct.h
  group src/features/ipd
    ../../src/features/ipd/: ipd.h ipd_config.c ipd_config.h ipd_funcs.c ipd_funcs.h ipd_struct.h libipd_iar.a
  group src/features/opd
    ../../src/features/opd/: opd_cl.h opd_cl_config.h opd_cl_funcs.c opd_cl_funcs.h opd_cl_struct.h opd_ol.h opd_ol_config.h opd_ol_funcs.c opd_ol_funcs.h opd_ol_struct.h
  group src/features/sim
    ../../src/features/sim/: libsim_iar.a sim_config.c sim_config.h sim_funcs.c sim_funcs.h sim_h_defs.h sim_h_funcs.c sim_h_funcs.h sim_h_funcs_ext.h sim_h_struct.h sim_i_defs.h sim_i_funcs.c sim_i_funcs.h sim_i_struct.h sim_sm.c sim_struct.h sim_v_defs.h sim_v_funcs.c sim_v_funcs.h sim_v_struct.h
  group src/features/stalldet
    ../../src/features/stalldet/: stalldet.h stalldet_config.h stalldet_funcs.c stalldet_funcs.h stalldet_struct.h
  group src/isr
    ../../src/isr/: isr_adc.c isr_config.h isr_funcs.c isr_funcs.h isr_gpioA.c isr_gpioB.c isr_gpioC.c isr_gpioD.c isr_stubs.c isr_systick.c isr_timerA.c isr_timerB.c isr_timerC.c isr_timerD.c
  group src/math
    ../../src/math/: calc_angle.h calc_speed.h circle_table.c fast_div.h fix16.c fix16.h fix16_sqrt.c int64.h maths.c maths.h pid.c pid.h sin_table.c sqrt.h trig.c trig.h utils.h
  group src/mpos
    ../../src/mpos/: mpos_config.h mpos_funcs.h mpos_misc.h mpos_struct.h
  group src/mpos/aligngo
    ../../src/mpos/aligngo/: aligngo_funcs.c aligngo_funcs.h aligngo_struct.h
  group src/mpos/estimator
    ../../src/mpos/estimator/: anglediff.c anglediff.h anglediff_lib.h est_sim2est.h lbg1.h lbg1_funcs.c lbg1_funcs.h lbg1_pll.h lbg1_pll_struct.h lbg1_struct.h libestimator_iar.a
  group src/mpos/hall
    ../../src/mpos/hall/: hall_funcs.c hall_funcs.h hall_hall2est.h hall_io_config.h hall_sim2hall.h hall_struct.h hall_timer_config.h
  group src/param
    ../../src/param/: param.h param_calc.h param_def_init.c param_default.h param_funcs.h param_read.c param_user_1.h param_write.c
  group src/startup
    ../../src/startup/: startup_aligngo2est_funcs.h startup_aligngo2est_struct.h startup_hall_funcs.h startup_hall_struct.h
