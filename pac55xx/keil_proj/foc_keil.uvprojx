# Keil uVision project foc_keil.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: PAC5532 Active-Semi
  pack: Active-Semi.PAC55XX.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PAC_FOC +hex
  BeforeMake: ..\..\pre_build.bat .\ keil
  AfterMake: "$K\ARM\ARMCC\bin\fromelf.exe" --bincombined "!L" --output="$L\@L.bin"
  AfterMake: "..\..\crc_insert" "4" "0x0" "$L\@L.bin" "!L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: KEIL, inline=__INLINE
  c misc: --diag_suppress=1035
  c include: .\;..\;..\..\;..\cmsis_core;..\board;..\device;..\pac55xx_sdk;..\pac55xx_sdk\boot_keil;..\pac55xx_sdk\driver;..\pac55xx_sdk\peripheral;..\pac55xx_sdk\device;..\..\src;..\..\src\app;..\..\src\comm;..\..\src\comm\ppm;..\..\src\comm\uart_gui;..\..\src\control;..\..\src\debug;..\..\src\features;..\..\src\features\autotune;..\..\src\features\flash_crc_test;..\..\src\features\ipd;..\..\src\features\opd;..\..\src\features\power;..\..\src\features\sim;..\..\src\features\stalldet;..\..\src\isr;..\..\src\math;..\..\src\mpos;..\..\src\mpos\estimator;..\..\src\param;..\..\src\startup;..\..\src\mpos\aligngo;..\..\src\mpos\hall;..\..\src\mpos\qep;..\..\src\features\halltune;..\..\src\comm\push_button;..\..\src\comm\lin_gui;..\..\src\comm\can_gui;..\..\src\features\forceang;..\..\src\features\flash_read_wr;..\..\src\features\flashrw;..\..\src\features\flashdemo;..\..\src\features\buzz;..\..\src\debug\RTT;..\..\src\mpos\trap;..\..\src\can;..\..\src\driverstrategy;..\..\src\usercom;..\..\src\vsm
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\foc_keil.sct
  link misc: --diag_suppress 6314
  group cmsis_core
    ../cmsis_core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group pac55xx_sdk
    ../pac55xx_sdk/boot_keil/: startup_pac55XX_keil.s system_pac5xxx.c system_pac5xxx.h
    ../pac55xx_sdk/driver/: pac5xxx_driver_adc.c pac5xxx_driver_adc.h pac5xxx_driver_config.h pac5xxx_driver_gpio.c pac5xxx_driver_gpio.h pac5xxx_driver_memory.h pac5xxx_driver_socbridge.c pac5xxx_driver_socbridge.h pac5xxx_driver_system.c pac5xxx_driver_system.h pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_timer.c pac5xxx_driver_timer.h pac5xxx_driver_uart.c pac5xxx_driver_uart.h
    ../pac55xx_sdk/peripheral/: pac5xxx.h pac5xxx_adc.h pac5xxx_can.h pac5xxx_crc.h pac5xxx_gp_timers.h pac5xxx_gpio.h pac5xxx_i2c.h pac5xxx_memory.h pac5xxx_rtc.h pac5xxx_scc.h pac5xxx_ssp.h pac5xxx_tile_driver_manager.h pac5xxx_tile_power_manager.h pac5xxx_tile_signal_manager.h pac5xxx_tile_system_manager.h pac5xxx_timers.h pac5xxx_uart.h pac5xxx_wwdt.h
    ../pac55xx_sdk/device/: pac5523.h pac5532.h pac5524.h pac5527.h pac5556.h pac5526.h
  group app
    ../../src/app/: adccal.h adc_sample.h app_control_sm.h app_funcs.c app_funcs.h app_main_sm.c app_mainsub_sm.c app_struct.h driver_funcs.c driver_funcs.h fault.c fault.h fault_struct.h motor_struct.h pac_init.c pac_init.h state_struct.h status_struct.h vbus_funcs.c vbus_funcs.h
  group board
    ../board/: board.h board_options.h board_custom_1.c board_custom_1.h board_pac5523evk1.c board_pac5523evk1.h board_pac5523Aevk1.c board_pac5523Aevk1.h board_pac5524evk1.c board_pac5524evk1.h board_pac5526evk1.c board_pac5526evk1.h board_pac5527evk1.c board_pac5527evk1.h board_pac5532evk1.c board_pac5532evk1.h board_pac5532Bevk1.c board_pac5532Bevk1.h board_pac5556evk1.c board_pac5556evk1.h board_pac5556Aevk1.c board_pac5556Aevk1.h board_pac5523evk1_1_1shunt.c board_pac5523evk1_1_1shunt.h board_pac5523Aevk1_1_1shunt.c board_pac5523Aevk1_1_1shunt.h board_pac5523evk1_1_1shunt_pwr2.c board_pac5523evk1_1_1shunt_pwr2.h board_pac5523Aevk1_1_1shunt_pwr2.c board_pac5523Aevk1_1_1shunt_pwr2.h board_pac5524evk1_1_1shunt.c board_pac5524evk1_1_1shunt.h board_pac5524evk1_1_1shunt_pwr2.c board_pac5524evk1_1_1shunt_pwr2.h board_pac5532evk1_1shunt.c board_pac5532evk1_1shunt.h board_pac5532Bevk1_1shunt.c board_pac5532Bevk1_1shunt.h board_pac5556evk1_1shunt.c board_pac5556evk1_1shunt.h board_pac5556Aevk1_1shunt.c board_pac5556Aevk1_1shunt.h board_pac5524rdps.c board_pac5524rdps.h board_pac5527hcrd1.c board_pac5527hcrd1.h board_pac5524Aevk1.c board_pac5524Aevk1.h board_pac5526Aevk1.c board_pac5526Aevk1.h board_pac5527Aevk1.c board_pac5527Aevk1.h
  group comm
    ../../src/comm/: comm.h comm_funcs.c comm_funcs.h comm_struct.h
    ../../src/comm/can_gui/: can_gui.c can_gui.h
    ../../src/comm/lin_gui/: lin_gui.c lin_gui.h
    ../../src/comm/uart_gui/: uart_gui.c uart_gui.h
    ../../src/comm/ppm/: ppm.c ppm.h ppm_struct.h
    ../../src/comm/push_button/: push_button.c push_button.h
  group control
    ../../src/control/: control_loop.c control_loop.h control_1shunt_funcs.h control_1shunt_struct.h control_1shunt_funcs_asym.h control_1shunt_funcs_asym2.h control_1shunt_funcs_extn.h control_3shunt_funcs.h control_3shunt_struct.h control_funcs.c control_funcs.h control_power_funcs.h control_power1.h control_power1_funcs.h control_power1_struct.h control_power2_funcs.h control_power2_struct.h control_sm.h control_struct.h foc_config.c foc_config.h foc_funcs.c foc_funcs.h foc_math.h foc_struct.h foc.h harmonic_inj_funcs.h harmonic_inj_libfuncs.h harmonic_inj_struct.h libcontrol_keil_m4.lib mod.h mod_gen.h mod_gen_funcs.h mod_ovm.h mod_ovm_funcs.c mod_ovm_funcs.h mod_ovm_struct.h mod_svm.h mtpa_funcs.c mtpa_funcs.h mtpa.h mtpa_struct.h
  group debug
    ../../src/debug/: control_check.h debug.c debug.h debug_dac.c debug_dac.h debug_das.c debug_das.h debug_display.c debug_display.h debug_export.c debug_export.h stack_check.c stack_check.h tm.h tm_auto_speed.c tm_paramcheck.c debug_paramwrite.h debug_capture.h debug_capture.c
    ../device/: debug_io.h
    ../../src/debug/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c USER_RTT.h
  group device
    ../device/: family_55xx.c family_55xx.h device_5523.h device_5523A.h device_5524.h device_5526.h device_5527.h device_5532.h device_5532B.h device_5556.h device_5556A.h device_5523.c device_5523A.c device_5524.c device_5526.c device_5527.c device_5532.c device_5532B.c device_5556.c device_5556A.c device_5524A.c device_5524A.h device_5526A.c device_5526A.h device_5527A.c device_5527A.h
  group features
    ../../src/features/: dcbus_check.c dcbus_check.h fw_funcs.c fw_funcs.h fw_struct.h speed_check.c speed_check.h watchdog.c watchdog.h satmon.c satmon.h
    ../../src/features/flash_crc_test/: checksum.c checksum.h flash_crc_reset_handler.c flash_crc_checksum.c pac5xxx_flash_test.c pac5xxx_flash_test.h
    ../../src/features/ipd/: ipd_config.c ipd_config.h ipd_struct.h ipd_funcs.c ipd_funcs.h ipd.h libipd_keil_m4.lib
    ../../src/features/opd/: opd_cl.h opd_cl_config.h opd_cl_funcs.c opd_cl_funcs.h opd_cl_struct.h opd_ol.h opd_ol_config.h opd_ol_funcs.c opd_ol_funcs.h opd_ol_struct.h
    ../../src/features/sim/: sim_sm.c sim_struct.h sim_config.c sim_config.h sim_funcs.c sim_funcs.h sim_i_defs.h sim_i_funcs.c sim_i_funcs.h sim_i_struct.h sim_v_defs.h sim_v_funcs.c sim_v_funcs.h sim_v_struct.h sim_h_defs.h sim_h_funcs.c sim_h_funcs.h sim_h_funcs_ext.h sim_h_struct.h sim_q_defs.h sim_q_funcs.c sim_q_funcs.h sim_q_struct.h libsim_keil_m4.lib
    ../../src/features/stalldet/: stalldet.h stalldet_config.h stalldet_funcs.c stalldet_funcs.h stalldet_struct.h
    ../../src/features/halltune/: halltune_funcs.c halltune_funcs.h halltune_struct.h
    ../../src/features/autotune/: atune_funcs.c atune_funcs.h atune_libfuncs.h atune_struct.h libautotune_keil_m4.lib mid1_funcs.c mid1_funcs.h mid2_funcs.c mid2_funcs.h
    ../../src/features/forceang/: forceang_funcs.c forceang_funcs.h forceang_struct.h
    ../../src/features/flashdemo/: flashdemo.c flashdemo.h
    ../../src/features/flashrw/: flashrw_crc8.c flashrw_crc8.h flashrw_funcs.c flashrw_funcs.h flashrw_struct.h flashrw_defs.h flashrw_fxadr_ctr.c flashrw_fxadr_ctr.h flash_dyadr_ctr.c flash_dyadr_ctr.h
    ../../src/features/buzz/: buzz_funcs.c buzz_funcs.h buzz_melodies.c buzz_struct.h
  group isr
    ../../src/isr/: isr_adc.c isr_gpioA.c isr_gpioB.c isr_stubs.c isr_systick.c isr_timerA.c isr_timerB.c isr_timerC.c isr_timerD.c isr_qepC.c isr_timerGPTA.c isr_gpioC.c isr_gpioD.c isr_qepD.c isr_funcs.c isr_funcs.h isr_struct.h
  group math
    ../../src/math/: calc_angle.h calc_speed.h circle_table.c fast_div.h fix16.c fix16.h fix16_sqrt.c int64.h maths.c maths.h pid.c pid.h sin_table.c sqrt.h trig.h utils.h trig.c
  group mpos
    ../../src/mpos/: mpos_funcs.h mpos_struct.h mpos_config.h mpos_misc.h
    ../../src/mpos/estimator/: libestimator_keil_m4.lib lbg1.h lbg1_funcs.c lbg1_funcs.h lbg1_struct.h lbg1_pll.h lbg1_pll_struct.h anglediff.c anglediff.h anglediff_lib.h est_sim2est.h
    ../../src/mpos/aligngo/: aligngo_funcs.c aligngo_funcs.h aligngo_struct.h
    ../../src/mpos/hall/: hall_funcs.c hall_funcs.h hall_hall2est.h hall_io_config.h hall_sim2hall.h hall_struct.h hall_timer_config.h
    ../../src/mpos/qep/: qep_funcs.c qep_funcs.h qep_io_config.h qep_struct.h qep_timer_config.h qep_qep2est.h qep_sim2qep.h qep_lin_flashrw.c qep_lin_flashrw.h
    ../../src/mpos/trap/: trap_funcs.c trap_funcs.h trap_struct.h trap_trap2est.h
  group param
    ../../src/param/: param.h param_calc.h param_default.h param_user_1.h param_def_init.c param_funcs.h param_read.c param_write.c
  group src
    ../../src/: main.c config_app.h config_debug.h config_features.h config_options.h
    ../board/: config_board.h
    ../../: project_version.h
  group startup
    ../../src/startup/: startup_aligngo2est_funcs.h startup_aligngo2est_struct.h startup_aligngo2qep_funcs.h startup_aligngo2qep_struct.h startup_hall_funcs.h startup_hall_struct.h startup_aligngo2trap_funcs.h startup_aligngo2trap_struct.h
  group driver_strategy
    ../../src/driverstrategy/: Driver_Strategy.c Driver_Strategy.h rtwtypes.h
  group vsm
    ../../src/vsm/: VSM_control.c VSM_control.h
